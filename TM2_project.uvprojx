# Keil uVision project TM2_project.uvprojx, settings and files
target TM2_project (6160000::V6.16::ARMCLANG)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TM2_project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./: main.c spi.c klaw.c tpm_pcm.c led.c i2c.c lcd1602.c
  group inc
    ./: spi.h klaw.h music_samples.h tpm_pcm.h led.h i2c.h lcd1602.h
software components: CMSIS Driver:I2C:Custom 1.0.0, CMSIS Driver:SPI:Custom 1.0.0, CMSIS:CORE 5.5.0, Device:Startup 1.0.0
